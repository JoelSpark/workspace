<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>stream_rx</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>250</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interpolation</value></param>
<param><key>value</key><value>96</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wav_path</value></param>
<param><key>value</key><value>'/home/nanosatisfi/data/audio' + timestamp + '.wav'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timestamp</value></param>
<param><key>value</key><value> str(time.gmtime().tm_year) + time.strftime("%m%d-%H%M",time.gmtime())</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>doppler_shift</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>iq_path</value></param>
<param><key>value</key><value>'/home/nanosatisfi/data/iq/' + timestamp + '.iq'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>437e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_error</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>uhf_rx_gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>predict_port</value></param>
<param><key>value</key><value>1210</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>control_port</value></param>
<param><key>value</key><value>5001</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fwd_to_ip</value></param>
<param><key>value</key><value>"192.168.0.249"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>satellite_name</value></param>
<param><key>value</key><value>39413</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>interpolation</value></param>
<param><key>decim</key><value>decimation</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate/decimation*interpolation</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>-doppler_shift-freq_error</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq,10e6)</value></param>
<param><key>gain0</key><value>uhf_rx_gain</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>satisfi_predict_query</key>
<param><key>id</key><value>satisfi_predict_query_0</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>sat_name</key><value>satellite_name</value></param>
<param><key>predict_ip</key><value>predict_hostname</value></param>
<param><key>predict_port</key><value>predict_port</value></param>
<param><key>xml_ip</key><value>127.0.0.1</value></param>
<param><key>xml_port</key><value>control_port</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0</value></param>
<param><key>addr</key><value>localhost</value></param>
<param><key>port</key><value>control_port</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>500</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>samp_rate/decim*0.4</value></param>
<param><key>width</key><value>samp_rate/decim*0.4*0.2</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>predict_hostname</value></param>
<param><key>value</key><value>127.0.0.1</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fwp_ip_addr</value></param>
<param><key>value</key><value>10.4.1.2</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ipaddr</key><value>fwp_ip_addr</value></param>
<param><key>port</key><value>8888</value></param>
<param><key>psize</key><value>0</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>satisfi_predict_query_0</sink_block_id><source_key>strobe</source_key><sink_key>trig</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
