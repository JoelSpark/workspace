<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>postprocess</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>detect_level</value></param>
<param><key>value</key><value>0.002</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>40000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wpm</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb0</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['Baseband', 'Morse Decoder']</value></param>
<param><key>grid_pos</key><value>[0,0,1,1]</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>width</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>avg_len</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>1</value></param>
<param><key>min</key><value>1</value></param>
<param><key>max</key><value>500</value></param>
<param><key>num_steps</key><value>500</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>notebook</key><value>nb0,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>wid2</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>80</value></param>
<param><key>min</key><value>20</value></param>
<param><key>max</key><value>200</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>notebook</key><value>nb0,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>width</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>200</value></param>
<param><key>min</key><value>100</value></param>
<param><key>max</key><value>2000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>notebook</key><value>nb0,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tone_freq</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>1000</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>notebook</key><value>nb0,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq_adjust</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-10000</value></param>
<param><key>max</key><value>10000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>notebook</key><value>nb0,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>volume</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>notebook</key><value>nb0,0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>noise</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>notebook</key><value>nb0,0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>96000</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>tone_freq</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>12</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>decoder_tone_freq</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>96000</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>volume</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>detect_level</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>detect_level*2</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>detect_level*3</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0_0_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>9600</value></param>
<param><key>v_scale</key><value>.001</value></param>
<param><key>v_offset</key><value>.004</value></param>
<param><key>t_scale</key><value>0.08</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>grid_pos</key><value>[0,0,1,2]</value></param>
<param><key>notebook</key><value>nb0,1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_STRIPCHART</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>hilbert_fc</key>
<param><key>id</key><value>hilbert_fc_0_0</value></param>
<param><key>num_taps</key><value>512</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>satisfi_morse_decode</key>
<param><key>id</key><value>satisfi_morse_decode_0</value></param>
<param><key>wpm</key><value>wpm</value></param>
<param><key>samp_rate</key><value>9600</value></param>
<param><key>thresh</key><value>thresh</value></param>
<param><key>thresh_detect_true_level</key><value>1</value></param>
<param><key>char_detect_true_level</key><value>1</value></param>
<param><key>letter_detect_true_level</key><value>1</value></param>
<param><key>avg_len</key><value>avg_len</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>decay</value></param>
<param><key>label</key><value>AGC3 Decay</value></param>
<param><key>value</key><value>1e-6</value></param>
<param><key>min</key><value>0.00000001</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>[1,0,1,1]</value></param>
<param><key>notebook</key><value>nb0,1</value></param>
</block>
<block>
<key>analog_agc3_xx</key>
<param><key>id</key><value>analog_agc3_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>attack_rate</key><value>attack</value></param>
<param><key>decay_rate</key><value>decay</value></param>
<param><key>reference</key><value>reference</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>100000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>attack</value></param>
<param><key>label</key><value>AGC3 Attack</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>min</key><value>0.00000001</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>[2,0,1,1]</value></param>
<param><key>notebook</key><value>nb0,1</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>noise</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>hilbert_fc</key>
<param><key>id</key><value>hilbert_fc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>num_taps</key><value>512</value></param>
</block>
<block>
<key>satisfi_morse_key</key>
<param><key>id</key><value>satisfi_morse_key_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>wpm</key><value>wpm</value></param>
<param><key>text</key><value>SAMPLE</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>-1000</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>amp</key><value>signal</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>-freq_adjust</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>40000</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>nb0,0</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>signal</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0.12</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>[2,1,1,1]</value></param>
<param><key>notebook</key><value>nb0,1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>96000</value></param>
<param><key>cutoff_freq</key><value>lpf2</value></param>
<param><key>width</key><value>50</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>lpf2</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>20</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>[3,1,1,1]</value></param>
<param><key>notebook</key><value>nb0,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>thresh</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0.004</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>[1,1,1,1]</value></param>
<param><key>notebook</key><value>nb0,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>reference</value></param>
<param><key>label</key><value>AGC3 Reference</value></param>
<param><key>value</key><value>0.015</value></param>
<param><key>min</key><value>0.00000001</value></param>
<param><key>max</key><value>5</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>[3,0,1,1]</value></param>
<param><key>notebook</key><value>nb0,1</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ipaddr</key><value>192.168.0.138</value></param>
<param><key>port</key><value>8888</value></param>
<param><key>psize</key><value>32768</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>rational_resampler_xxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decoder_tone_freq</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>satisfi_morse_decode_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1</source_block_id><sink_block_id>wxgui_scopesink2_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>wxgui_scopesink2_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>satisfi_morse_decode_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satisfi_morse_decode_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satisfi_morse_decode_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>hilbert_fc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hilbert_fc_0_0</source_block_id><sink_block_id>analog_agc3_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc3_xx_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>satisfi_morse_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hilbert_fc_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>satisfi_morse_key_0</source_block_id><sink_block_id>hilbert_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1</source_block_id><sink_block_id>blocks_multiply_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>satisfi_morse_key_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
