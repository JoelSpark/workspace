<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>morse_decode_hier</value></param>
<param><key>title</key><value>Morse Decoder</value></param>
<param><key>author</key><value>Joel Spark</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>satisfi</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filtercutoff</value></param>
<param><key>label</key><value>Power LPF Cutoff</value></param>
<param><key>value</key><value>80</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>thresh</value></param>
<param><key>label</key><value>Detection Threshold</value></param>
<param><key>value</key><value>0.002</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dfreq</value></param>
<param><key>label</key><value>Decoder Frequency</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>wpm</value></param>
<param><key>label</key><value>Signal WPM (Paris Std)</value></param>
<param><key>value</key><value>50</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>value</key><value>96000</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>processed_signal</value></param>
<param><key>label</key><value>processed_signal</value></param>
<param><key>type</key><value>float</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>char_detect_0</value></param>
<param><key>label</key><value>thresh_detect</value></param>
<param><key>type</key><value>float</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>char_detect</value></param>
<param><key>label</key><value>char_detect</value></param>
<param><key>type</key><value>float</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1</value></param>
<param><key>label</key><value>letter_detect</value></param>
<param><key>type</key><value>float</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>decoder_tone_freq</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
<param><key>freq</key><value>-dfreq</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>filtercutoff</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>satisfi_morse_decode</key>
<param><key>id</key><value>satisfi_morse_decode_0</value></param>
<param><key>wpm</key><value>wpm</value></param>
<param><key>samp_rate</key><value>samp_rate/10</value></param>
<param><key>thresh</key><value>thresh</value></param>
<param><key>thresh_detect_true_level</key><value>1</value></param>
<param><key>char_detect_true_level</key><value>1</value></param>
<param><key>letter_detect_true_level</key><value>1</value></param>
<param><key>avg_len</key><value>1</value></param>
</block>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>satisfi_morse_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satisfi_morse_decode_0</source_block_id><sink_block_id>processed_signal</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>decoder_tone_freq</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satisfi_morse_decode_0</source_block_id><sink_block_id>char_detect_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satisfi_morse_decode_0</source_block_id><sink_block_id>char_detect</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satisfi_morse_decode_0</source_block_id><sink_block_id>pad_sink_0_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
</flow_graph>
